# Keil uVision project stm32f103rct6_car.uvprojx, settings and files
target stm32f103rct6_car (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF)   CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: stm32f103rct6_car +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c misc: --no-multibyte-chars
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../Hardware;../User/OLED;../User/PID;../wit_c_sdk
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c dma.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Hardware
    ../Hardware/: Delay.c Delay.h headfile.h Communication.c Communication.h No_Mcu_Ganv_Grayscale_Sensor.c No_Mcu_Ganv_Grayscale_Sensor_Config.h sys.c sys.h Key.c Key.h Encoder.c Encoder.h Bluetooth.c Bluetooth.h
  group User
    ../User/OLED/: OLED.c OLED.h OLED_Data.c OLED_Data.h
    ../User/PID/: PID.c PID.h
  group wit_c_sdk
    ../wit_c_sdk/: wit_c_sdk.c wit_c_sdk.h wit_motion.c wit_motion.h REG.h
software components: CMSIS:CORE 6.1.0

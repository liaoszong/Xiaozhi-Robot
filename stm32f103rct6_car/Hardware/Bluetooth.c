#include "headfile.h"

// 蓝牙句柄
Bluetooth_HandleTypeDef hbluetooth = {0};

// 有效命令列表
static const char valid_commands[] = "AEGCZHBDF";

/**
 * @brief 初始化蓝牙模�?
 * @param huart 蓝牙使用的UART句柄
 */
void Bluetooth_Init(UART_HandleTypeDef *huart)
{
    // 停止可能正在进行的DMA传输
    HAL_UART_DMAStop(huart);
    
    // 启动空闲中断接收
    HAL_UARTEx_ReceiveToIdle_DMA(huart, hbluetooth.rx_buffer, sizeof(hbluetooth.rx_buffer));
    
    // 禁用半传输中�?
    if (huart->hdmarx != NULL) {
        __HAL_DMA_DISABLE_IT(huart->hdmarx, DMA_IT_HT);
    }
    
    // 初始化命令缓冲区
    hbluetooth.cmd_index = 0;
    hbluetooth.read_index = 0;
    hbluetooth.process_size = 0;
    hbluetooth.last_valid_cmd = CMD_STOP;
    memset(hbluetooth.cmd_buffer, 0, BLUETOOTH_CMD_BUFFER_SIZE);
    memset(hbluetooth.process_buffer, 0, BLUETOOTH_RX_BUFFER_SIZE);
    
    // 发送就绪消�?
    const char* ready_msg = "Persistent Car Control Ready!\r\n";
    const char* help_msg = "Commands: A=Forward, E=Back, G=Left, C=Right, Z=Stop\r\n";
    Bluetooth_SendString(ready_msg);
    Bluetooth_SendString(help_msg);
}

/**
 * @brief 反初始化蓝牙模块
 * @param huart 蓝牙使用的UART句柄
 */
void Bluetooth_DeInit(UART_HandleTypeDef *huart)
{
    HAL_UART_DMAStop(huart);
    memset(&hbluetooth, 0, sizeof(Bluetooth_HandleTypeDef));
}

/**
 * @brief 蓝牙接收事件回调函数
 * @param huart UART句柄
 * @param Size 接收到的数据大小
 */
void Bluetooth_RxEventCallback(UART_HandleTypeDef *huart, uint16_t Size)
{
    if (huart->Instance == USART3)  // 假设蓝牙连接到USART3
    {
        uint16_t copy_size = Size;
        if (copy_size >= sizeof(hbluetooth.process_buffer)) {
            copy_size = sizeof(hbluetooth.process_buffer) - 1;
        }

        // Keep a stable copy for the main loop before DMA reuses rx_buffer.
        memcpy(hbluetooth.process_buffer, hbluetooth.rx_buffer, copy_size);
        hbluetooth.process_buffer[copy_size] = '\0';
        hbluetooth.process_size = copy_size;
        hbluetooth.rx_size = Size;
        hbluetooth.rx_flag = 1;
        
        // 确保字符串以NULL结尾
        if (Size < sizeof(hbluetooth.rx_buffer))
            hbluetooth.rx_buffer[Size] = '\0';
        else
            hbluetooth.rx_buffer[sizeof(hbluetooth.rx_buffer)-1] = '\0';
        
        // 重新启动接收
        HAL_UARTEx_ReceiveToIdle_DMA(huart, hbluetooth.rx_buffer, sizeof(hbluetooth.rx_buffer));
    }
}

/**
 * @brief 检查字符是否为有效命令
 * @param c 要检查的字符
 * @return 1-有效, 0-无效
 */
static uint8_t IsValidCommand(char c)
{
    for (int i = 0; i < strlen(valid_commands); i++) {
        if (c == valid_commands[i])
            return 1;
    }
    return 0;
}

/**
 * @brief 增强命令过滤 - 只提取孤立的命令字符
 * @return 1-找到有效命令, 0-未找�?
 */
uint8_t Bluetooth_ProcessCommands(void)
{
    uint8_t command_found = 0;
    uint8_t local_buffer[BLUETOOTH_RX_BUFFER_SIZE];
    uint16_t local_size;

    // Copy the completed frame once; DMA can refill rx_buffer immediately after IRQ.
    __disable_irq();
    local_size = hbluetooth.process_size;
    if (local_size >= sizeof(local_buffer)) {
        local_size = sizeof(local_buffer) - 1;
    }
    memcpy(local_buffer, hbluetooth.process_buffer, local_size);
    hbluetooth.rx_flag = 0;
    __enable_irq();

    local_buffer[local_size] = '\0';

    for (int i = 0; i < local_size; i++) {
        char current_char = local_buffer[i];

        if (IsValidCommand(current_char)) {
            uint8_t prev_ok = 1;
            if (i > 0) {
                char prev_char = local_buffer[i-1];
                if ((prev_char >= 'A' && prev_char <= 'Z') ||
                    (prev_char >= 'a' && prev_char <= 'z') ||
                    (prev_char >= '0' && prev_char <= '9')) {
                    prev_ok = 0;
                }
            }

            uint8_t next_ok = 1;
            if (i < local_size - 1) {
                char next_char = local_buffer[i+1];
                if ((next_char >= 'A' && next_char <= 'Z') ||
                    (next_char >= 'a' && next_char <= 'z') ||
                    (next_char >= '0' && next_char <= '9')) {
                    next_ok = 0;
                }
            }

            if (prev_ok && next_ok && hbluetooth.cmd_index < BLUETOOTH_CMD_BUFFER_SIZE - 1) {
                hbluetooth.cmd_buffer[hbluetooth.cmd_index++] = current_char;
                command_found = 1;
            }
        }
    }

    return command_found;
}

/**
 * @brief 获取下一个命�?
 * @return 命令字符, 0-无命�?
 */
char Bluetooth_GetNextCommand(void)
{
    if (hbluetooth.read_index < hbluetooth.cmd_index) {
        char cmd = hbluetooth.cmd_buffer[hbluetooth.read_index++];

        if (hbluetooth.read_index >= hbluetooth.cmd_index) {
            hbluetooth.cmd_index = 0;
            hbluetooth.read_index = 0;
            memset(hbluetooth.cmd_buffer, 0, BLUETOOTH_CMD_BUFFER_SIZE);
        }

        return cmd;
    }

    return 0;
}

/**
 * @brief 检查是否有待处理命�?
 * @return 1-有待处理命令, 0-�?
 */
uint8_t Bluetooth_HasPendingCommands(void)
{
    return (hbluetooth.read_index < hbluetooth.cmd_index);
}

/**
 * @brief 获取最后一个有效命�?
 * @return 最后一个有效命令字�?
 */
char Bluetooth_GetLastValidCommand(void)
{
    return hbluetooth.last_valid_cmd;
}

/**
 * @brief 设置最后一个有效命�?
 * @param cmd 命令字符
 */
void Bluetooth_SetLastValidCommand(char cmd)
{
    if (IsValidCommand(cmd)) {
        hbluetooth.last_valid_cmd = cmd;
    }
}

/**
 * @brief 检查数据是否就�?
 * @return 1-数据就绪, 0-无数�?
 */
uint8_t Bluetooth_DataReady(void)
{
    return hbluetooth.rx_flag;
}

/**
 * @brief 清除数据就绪标志
 */
void Bluetooth_ClearFlag(void)
{
    hbluetooth.rx_flag = 0;
}

/**
 * @brief 发送字符串数据
 * @param data 要发送的字符�?
 */
void Bluetooth_SendString(const char* data)
{
    HAL_UART_Transmit(&huart3, (uint8_t*)data, strlen(data), 1000);
}

/**
 * @brief 格式化发送数�?
 * @param format 格式字符�?
 * @param ... 可变参数
 */
void Bluetooth_Printf(const char *format, ...)
{
    va_list args;
    va_start(args, format);
    char buffer[256];
    int len = vsnprintf(buffer, sizeof(buffer), format, args);
    va_end(args);

    if (len > 0) {
        Bluetooth_SendString(buffer);
    }
}
